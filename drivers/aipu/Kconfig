## drivers/aipu/Kconfig
```kconfig
# linux/drivers/aipu
menuconfig MAIN_AIPU
	tristate "https://github.com/Icenowy/zhouyi-mainline"
  default m
```
